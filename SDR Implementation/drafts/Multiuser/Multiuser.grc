options:
  parameters:
    author: Rumeth Samarasinghe
    generate_options: qt_gui
    id: Multiuser
    output_language: python
    title: Lets See how this works
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''1110000101011010111010001001001111100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''1110000101011010111010001001001111100001010110101110100010010011'''
  states: {}
- name: access_key_1
  id: variable
  parameters:
    value: '''1110000101011010111010001001001111100001010110101110100010010011'''
  states: {}
- name: damp_fac
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: damp_fac_0
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: damp_fac_1
  id: variable
  parameters:
    value: '0.707'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: excess_bw_0
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: excess_bw_1
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_1
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0_0
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_0_1
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_1
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: max_dev_2
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts_1
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: phase_bw_0
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: phase_bw_1
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_0
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qpsk_1
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j] '
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rrc_taps_1
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    comment: |-
      taps are basically the 
      multipath impulse response 
      of your channel: how each
       transmitted symbol echoes 
      into the future
    value: '[0.6,0.4+0.2j,0.3-0.5j]'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {}
- name: user_1
  id: variable
  parameters:
    value: '''B1'''
  states: {}
- name: user_2
  id: variable
  parameters:
    value: '''A1'''
  states: {}
- name: user_3
  id: variable
  parameters:
    value: '''00'''
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_adaptive_algorithm_0_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_adaptive_algorithm_0_1
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    comment: |-
      Simulated channel
      Block tag propogation 
      set to off
      because realistically
      over air transmission 
      doesnt preserve metadata
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"1110000101011010111010001001001111100001010110101110100010010011"'
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_1
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0_1
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_1_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_1_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_1_0_1
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_0_0_1
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_1
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_1_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_1_0_1
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      The Symbol Sync block 
      aligns the sample clock 
      at the receiver to the 
      symbol clock of the
       transmitter
    damping: damp_fac
    loop_bw: phase_bw
    max_dev: max_dev
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Sender (Queue + Persistent Seq + Len Header)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time
      import struct
      import random

      class blk(gr.basic_block):
          def __init__(self, max_payload_len=250, retry_limit=10, timeout_ms=300, base_backoff_ms=50):
              gr.basic_block.__init__(self, name='Reliable Sender (Queue)', in_sig=None, out_sig=None)

              self.max_payload_len = max_payload_len
              self.retry_limit = retry_limit
              self.timeout = timeout_ms / 1000.0
              self.base_backoff = base_backoff_ms / 1000.0

              # Current Transmission State
              self.dest_addr = 0x00
              self.src_addr = 0x00 
              self.global_seq = 0 
              
              self.msg_fragments = []
              self.fragment_index = 0
              self.retry_count = 0
              self.state = "IDLE"
              self.last_send_time = 0
              
              # === QUEUE SYSTEM ===
              # Stores tuples: {'dest': dest, 'src': src, 'data': payload_bytes}
              self.tx_queue = []
              
              self.lock = threading.Lock()
              self.stop_thread = False

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('addr_in'))
              self.message_port_register_in(pmt.intern('ack_in'))
              self.message_port_register_out(pmt.intern('packet_out'))
              self.message_port_register_out(pmt.intern('feedback_out'))

              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('addr_in'), self.handle_addr)
              self.set_msg_handler(pmt.intern('ack_in'), self.handle_ack)

              self.arq_thread = threading.Thread(target=self.run_arq_loop)
              self.arq_thread.daemon = True
              self.arq_thread.start()

          def __del__(self):
              self.stop_thread = True
              if self.arq_thread.is_alive(): self.arq_thread.join()

          def handle_addr(self, msg):
              """ Update the 'current' address registers. Used when a new message arrives. """
              if not pmt.is_pair(msg): return
              data = pmt.u8vector_elements(pmt.cdr(msg))
              if len(data) >= 2:
                  with self.lock:
                      self.dest_addr = data[0]
                      self.src_addr = data[1]

          def handle_msg(self, msg):
              """ 
              Handle new message input.
              If BUSY, add to Queue. If IDLE, start transmitting.
              """
              if not pmt.is_pair(msg): return
              payload_bytes = pmt.u8vector_elements(pmt.cdr(msg))
              if len(payload_bytes) == 0: return
              
              with self.lock:
                  # Create a job packet with the CURRENT addresses and payload
                  # We must capture addresses NOW because self.dest_addr might change later
                  job = {
                      'dest': self.dest_addr,
                      'src': self.src_addr,
                      'data': payload_bytes
                  }

                  if self.state == "IDLE":
                      # Start immediately
                      self.load_job(job)
                  else:
                      # Add to queue
                      self.tx_queue.append(job)

          def load_job(self, job):
              """ Helper: Loads a job into the active transmission buffers """
              # Restore the addresses for this specific message
              self.dest_addr = job['dest']
              self.src_addr = job['src']
              payload = job['data']
              
              self.msg_fragments = []
              for i in range(0, len(payload), self.max_payload_len):
                  self.msg_fragments.append(payload[i : i + self.max_payload_len])

              self.fragment_index = 0
              self.retry_count = 0
              self.state = "SENDING"
              self.last_send_time = 0

          def check_queue(self):
              """ Called after success/fail. Checks if more work exists. """
              if len(self.tx_queue) > 0:
                  # Pop next message and start
                  next_job = self.tx_queue.pop(0)
                  self.load_job(next_job)
              else:
                  self.state = "IDLE"

          def handle_ack(self, msg):
              if self.state == "IDLE": return
              if not pmt.is_pair(msg): return
              
              try:
                  ack_data = pmt.u8vector_elements(pmt.cdr(msg))
                  if len(ack_data) < 7: return 
                  if ack_data[2] != 1: return 

                  requested_seq = (ack_data[3] << 8) | ack_data[4]

                  with self.lock:
                      next_seq = (self.global_seq + 1) & 0xFFFF
                      if requested_seq == next_seq:
                          self.global_seq = next_seq
                          self.fragment_index += 1
                          self.retry_count = 0
                          
                          if self.fragment_index >= len(self.msg_fragments):
                              # === MSG DONE: SUCCESS ===
                              self.send_feedback(True)
                              # Check if there are more messages waiting
                              self.check_queue()
                          else:
                              self.state = "SENDING"
                              self.last_send_time = 0 
              except Exception: pass

          def send_packet(self):
              if self.fragment_index >= len(self.msg_fragments): return
              fragment = self.msg_fragments[self.fragment_index]
              ack_flag = 0
              fin_flag = 1 if (self.fragment_index == len(self.msg_fragments) - 1) else 0
              payload_len = len(fragment)

              header = struct.pack('>BBBHBB', self.dest_addr, self.src_addr, ack_flag, self.global_seq, fin_flag, payload_len)
              full_packet = list(header) + list(fragment)
              
              out_pmt = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(full_packet), full_packet))
              self.message_port_pub(pmt.intern('packet_out'), out_pmt)
              self.last_send_time = time.time()

          def send_feedback(self, success):
              status = "ACK" if success else "FAIL"
              self.message_port_pub(pmt.intern('feedback_out'), pmt.cons(pmt.PMT_NIL, pmt.intern(status)))

          def run_arq_loop(self):
              while not self.stop_thread:
                  time.sleep(0.01)
                  with self.lock:
                      if self.state == "SENDING" or self.state == "WAIT_ACK":
                          wait_threshold = self.timeout
                          if self.retry_count > 0:
                              exponent = min(self.retry_count, 4)
                              wait_threshold += random.uniform(0, self.base_backoff * (2 ** (exponent - 1)))

                          if self.last_send_time == 0 or (time.time() - self.last_send_time) > wait_threshold:
                              if self.retry_count < self.retry_limit:
                                  self.send_packet()
                                  self.state = "WAIT_ACK"
                                  if self.last_send_time != 0: self.retry_count += 1
                              else:
                                  # === MSG DONE: FAILED ===
                                  self.send_feedback(False)
                                  # Even if failed, check queue for next message
                                  self.check_queue()
    base_backoff_ms: '10'
    max_payload_len: '250'
    retry_limit: '15'
    timeout_ms: '100'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Sender (Queue + Persistent Seq + Len Header)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time
      import struct
      import random

      class blk(gr.basic_block):
          def __init__(self, max_payload_len=250, retry_limit=10, timeout_ms=300, base_backoff_ms=50):
              gr.basic_block.__init__(self, name='Reliable Sender (Queue)', in_sig=None, out_sig=None)

              self.max_payload_len = max_payload_len
              self.retry_limit = retry_limit
              self.timeout = timeout_ms / 1000.0
              self.base_backoff = base_backoff_ms / 1000.0

              # Current Transmission State
              self.dest_addr = 0x00
              self.src_addr = 0x00 
              self.global_seq = 0 
              
              self.msg_fragments = []
              self.fragment_index = 0
              self.retry_count = 0
              self.state = "IDLE"
              self.last_send_time = 0
              
              # === QUEUE SYSTEM ===
              # Stores tuples: {'dest': dest, 'src': src, 'data': payload_bytes}
              self.tx_queue = []
              
              self.lock = threading.Lock()
              self.stop_thread = False

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('addr_in'))
              self.message_port_register_in(pmt.intern('ack_in'))
              self.message_port_register_out(pmt.intern('packet_out'))
              self.message_port_register_out(pmt.intern('feedback_out'))

              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('addr_in'), self.handle_addr)
              self.set_msg_handler(pmt.intern('ack_in'), self.handle_ack)

              self.arq_thread = threading.Thread(target=self.run_arq_loop)
              self.arq_thread.daemon = True
              self.arq_thread.start()

          def __del__(self):
              self.stop_thread = True
              if self.arq_thread.is_alive(): self.arq_thread.join()

          def handle_addr(self, msg):
              """ Update the 'current' address registers. Used when a new message arrives. """
              if not pmt.is_pair(msg): return
              data = pmt.u8vector_elements(pmt.cdr(msg))
              if len(data) >= 2:
                  with self.lock:
                      self.dest_addr = data[0]
                      self.src_addr = data[1]

          def handle_msg(self, msg):
              """ 
              Handle new message input.
              If BUSY, add to Queue. If IDLE, start transmitting.
              """
              if not pmt.is_pair(msg): return
              payload_bytes = pmt.u8vector_elements(pmt.cdr(msg))
              if len(payload_bytes) == 0: return
              
              with self.lock:
                  # Create a job packet with the CURRENT addresses and payload
                  # We must capture addresses NOW because self.dest_addr might change later
                  job = {
                      'dest': self.dest_addr,
                      'src': self.src_addr,
                      'data': payload_bytes
                  }

                  if self.state == "IDLE":
                      # Start immediately
                      self.load_job(job)
                  else:
                      # Add to queue
                      self.tx_queue.append(job)

          def load_job(self, job):
              """ Helper: Loads a job into the active transmission buffers """
              # Restore the addresses for this specific message
              self.dest_addr = job['dest']
              self.src_addr = job['src']
              payload = job['data']
              
              self.msg_fragments = []
              for i in range(0, len(payload), self.max_payload_len):
                  self.msg_fragments.append(payload[i : i + self.max_payload_len])

              self.fragment_index = 0
              self.retry_count = 0
              self.state = "SENDING"
              self.last_send_time = 0

          def check_queue(self):
              """ Called after success/fail. Checks if more work exists. """
              if len(self.tx_queue) > 0:
                  # Pop next message and start
                  next_job = self.tx_queue.pop(0)
                  self.load_job(next_job)
              else:
                  self.state = "IDLE"

          def handle_ack(self, msg):
              if self.state == "IDLE": return
              if not pmt.is_pair(msg): return
              
              try:
                  ack_data = pmt.u8vector_elements(pmt.cdr(msg))
                  if len(ack_data) < 7: return 
                  if ack_data[2] != 1: return 

                  requested_seq = (ack_data[3] << 8) | ack_data[4]

                  with self.lock:
                      next_seq = (self.global_seq + 1) & 0xFFFF
                      if requested_seq == next_seq:
                          self.global_seq = next_seq
                          self.fragment_index += 1
                          self.retry_count = 0
                          
                          if self.fragment_index >= len(self.msg_fragments):
                              # === MSG DONE: SUCCESS ===
                              self.send_feedback(True)
                              # Check if there are more messages waiting
                              self.check_queue()
                          else:
                              self.state = "SENDING"
                              self.last_send_time = 0 
              except Exception: pass

          def send_packet(self):
              if self.fragment_index >= len(self.msg_fragments): return
              fragment = self.msg_fragments[self.fragment_index]
              ack_flag = 0
              fin_flag = 1 if (self.fragment_index == len(self.msg_fragments) - 1) else 0
              payload_len = len(fragment)

              header = struct.pack('>BBBHBB', self.dest_addr, self.src_addr, ack_flag, self.global_seq, fin_flag, payload_len)
              full_packet = list(header) + list(fragment)
              
              out_pmt = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(full_packet), full_packet))
              self.message_port_pub(pmt.intern('packet_out'), out_pmt)
              self.last_send_time = time.time()

          def send_feedback(self, success):
              status = "ACK" if success else "FAIL"
              self.message_port_pub(pmt.intern('feedback_out'), pmt.cons(pmt.PMT_NIL, pmt.intern(status)))

          def run_arq_loop(self):
              while not self.stop_thread:
                  time.sleep(0.01)
                  with self.lock:
                      if self.state == "SENDING" or self.state == "WAIT_ACK":
                          wait_threshold = self.timeout
                          if self.retry_count > 0:
                              exponent = min(self.retry_count, 4)
                              wait_threshold += random.uniform(0, self.base_backoff * (2 ** (exponent - 1)))

                          if self.last_send_time == 0 or (time.time() - self.last_send_time) > wait_threshold:
                              if self.retry_count < self.retry_limit:
                                  self.send_packet()
                                  self.state = "WAIT_ACK"
                                  if self.last_send_time != 0: self.retry_count += 1
                              else:
                                  # === MSG DONE: FAILED ===
                                  self.send_feedback(False)
                                  # Even if failed, check queue for next message
                                  self.check_queue()
    base_backoff_ms: '10'
    max_payload_len: '250'
    retry_limit: '15'
    timeout_ms: '100'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Sender (Queue + Persistent Seq + Len Header)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time
      import struct
      import random

      class blk(gr.basic_block):
          def __init__(self, max_payload_len=250, retry_limit=10, timeout_ms=300, base_backoff_ms=50):
              gr.basic_block.__init__(self, name='Reliable Sender (Queue)', in_sig=None, out_sig=None)

              self.max_payload_len = max_payload_len
              self.retry_limit = retry_limit
              self.timeout = timeout_ms / 1000.0
              self.base_backoff = base_backoff_ms / 1000.0

              # Current Transmission State
              self.dest_addr = 0x00
              self.src_addr = 0x00 
              self.global_seq = 0 
              
              self.msg_fragments = []
              self.fragment_index = 0
              self.retry_count = 0
              self.state = "IDLE"
              self.last_send_time = 0
              
              # === QUEUE SYSTEM ===
              # Stores tuples: {'dest': dest, 'src': src, 'data': payload_bytes}
              self.tx_queue = []
              
              self.lock = threading.Lock()
              self.stop_thread = False

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('addr_in'))
              self.message_port_register_in(pmt.intern('ack_in'))
              self.message_port_register_out(pmt.intern('packet_out'))
              self.message_port_register_out(pmt.intern('feedback_out'))

              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.set_msg_handler(pmt.intern('addr_in'), self.handle_addr)
              self.set_msg_handler(pmt.intern('ack_in'), self.handle_ack)

              self.arq_thread = threading.Thread(target=self.run_arq_loop)
              self.arq_thread.daemon = True
              self.arq_thread.start()

          def __del__(self):
              self.stop_thread = True
              if self.arq_thread.is_alive(): self.arq_thread.join()

          def handle_addr(self, msg):
              """ Update the 'current' address registers. Used when a new message arrives. """
              if not pmt.is_pair(msg): return
              data = pmt.u8vector_elements(pmt.cdr(msg))
              if len(data) >= 2:
                  with self.lock:
                      self.dest_addr = data[0]
                      self.src_addr = data[1]

          def handle_msg(self, msg):
              """ 
              Handle new message input.
              If BUSY, add to Queue. If IDLE, start transmitting.
              """
              if not pmt.is_pair(msg): return
              payload_bytes = pmt.u8vector_elements(pmt.cdr(msg))
              if len(payload_bytes) == 0: return
              
              with self.lock:
                  # Create a job packet with the CURRENT addresses and payload
                  # We must capture addresses NOW because self.dest_addr might change later
                  job = {
                      'dest': self.dest_addr,
                      'src': self.src_addr,
                      'data': payload_bytes
                  }

                  if self.state == "IDLE":
                      # Start immediately
                      self.load_job(job)
                  else:
                      # Add to queue
                      self.tx_queue.append(job)

          def load_job(self, job):
              """ Helper: Loads a job into the active transmission buffers """
              # Restore the addresses for this specific message
              self.dest_addr = job['dest']
              self.src_addr = job['src']
              payload = job['data']
              
              self.msg_fragments = []
              for i in range(0, len(payload), self.max_payload_len):
                  self.msg_fragments.append(payload[i : i + self.max_payload_len])

              self.fragment_index = 0
              self.retry_count = 0
              self.state = "SENDING"
              self.last_send_time = 0

          def check_queue(self):
              """ Called after success/fail. Checks if more work exists. """
              if len(self.tx_queue) > 0:
                  # Pop next message and start
                  next_job = self.tx_queue.pop(0)
                  self.load_job(next_job)
              else:
                  self.state = "IDLE"

          def handle_ack(self, msg):
              if self.state == "IDLE": return
              if not pmt.is_pair(msg): return
              
              try:
                  ack_data = pmt.u8vector_elements(pmt.cdr(msg))
                  if len(ack_data) < 7: return 
                  if ack_data[2] != 1: return 

                  requested_seq = (ack_data[3] << 8) | ack_data[4]

                  with self.lock:
                      next_seq = (self.global_seq + 1) & 0xFFFF
                      if requested_seq == next_seq:
                          self.global_seq = next_seq
                          self.fragment_index += 1
                          self.retry_count = 0
                          
                          if self.fragment_index >= len(self.msg_fragments):
                              # === MSG DONE: SUCCESS ===
                              self.send_feedback(True)
                              # Check if there are more messages waiting
                              self.check_queue()
                          else:
                              self.state = "SENDING"
                              self.last_send_time = 0 
              except Exception: pass

          def send_packet(self):
              if self.fragment_index >= len(self.msg_fragments): return
              fragment = self.msg_fragments[self.fragment_index]
              ack_flag = 0
              fin_flag = 1 if (self.fragment_index == len(self.msg_fragments) - 1) else 0
              payload_len = len(fragment)

              header = struct.pack('>BBBHBB', self.dest_addr, self.src_addr, ack_flag, self.global_seq, fin_flag, payload_len)
              full_packet = list(header) + list(fragment)
              
              out_pmt = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(full_packet), full_packet))
              self.message_port_pub(pmt.intern('packet_out'), out_pmt)
              self.last_send_time = time.time()

          def send_feedback(self, success):
              status = "ACK" if success else "FAIL"
              self.message_port_pub(pmt.intern('feedback_out'), pmt.cons(pmt.PMT_NIL, pmt.intern(status)))

          def run_arq_loop(self):
              while not self.stop_thread:
                  time.sleep(0.01)
                  with self.lock:
                      if self.state == "SENDING" or self.state == "WAIT_ACK":
                          wait_threshold = self.timeout
                          if self.retry_count > 0:
                              exponent = min(self.retry_count, 4)
                              wait_threshold += random.uniform(0, self.base_backoff * (2 ** (exponent - 1)))

                          if self.last_send_time == 0 or (time.time() - self.last_send_time) > wait_threshold:
                              if self.retry_count < self.retry_limit:
                                  self.send_packet()
                                  self.state = "WAIT_ACK"
                                  if self.last_send_time != 0: self.retry_count += 1
                              else:
                                  # === MSG DONE: FAILED ===
                                  self.send_feedback(False)
                                  # Even if failed, check queue for next message
                                  self.check_queue()
    base_backoff_ms: '10'
    max_payload_len: '250'
    retry_limit: '15'
    timeout_ms: '100'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: EchoWave Core (Fixed Source ID)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import sys
      import datetime
      from PyQt5 import QtWidgets, QtCore, QtGui

      class blk(gr.sync_block):
          def __init__(self, node_id_hex='A1'):
              """
              Args:
                  node_id_hex: The fixed 1-byte address for this node (Hex String, e.g., 'A1').
              """
              gr.sync_block.__init__(self,
                  name='EchoWave Core',
                  in_sig=None,
                  out_sig=None)

              self.node_id_hex = node_id_hex

              # Register Message Ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_in(pmt.intern("feedback_in"))
              self.message_port_register_out(pmt.intern("addr_out"))
              self.message_port_register_out(pmt.intern("msg_out"))

              # Register Handlers
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_in)
              self.set_msg_handler(pmt.intern("feedback_in"), self.handle_feedback)

              # Initialize GUI
              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)
              
              # Pass the fixed ID to the Window
              self.gui = EchoWaveWindow(self, f"Node {node_id_hex}", node_id_hex)
              self.gui.show()
              
              # Ghost Window Fix
              self.cleanup_timer = QtCore.QTimer()
              self.cleanup_timer.timeout.connect(self.hide_ghost_window)
              self.cleanup_timer.start(200)

          def hide_ghost_window(self):
              for w in QtWidgets.QApplication.topLevelWidgets():
                  if isinstance(w, QtWidgets.QMainWindow) and w != self.gui:
                      w.hide()
              self.cleanup_timer.stop()

          def process_user_input(self, dst_hex, text):
              """ 
              Process input from GUI.
              Source ID is now fixed from block param (self.node_id_hex).
              """
              try:
                  # Parse Hex to Int (0-255)
                  src_val = int(self.node_id_hex, 16) # Uses the fixed parameter
                  dst_val = int(dst_hex, 16)
                  
                  # 1. Address PDU: [Dest, Source]
                  addr_list = [dst_val, src_val]
                  pmt_addr = pmt.cons(pmt.make_dict(), pmt.init_u8vector(2, addr_list))
                  self.message_port_pub(pmt.intern("addr_out"), pmt_addr)
                  
                  # 2. Message PDU: UTF-8 Bytes
                  msg_bytes = [x for x in text.encode('utf-8')]
                  pmt_msg = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(msg_bytes), msg_bytes))
                  self.message_port_pub(pmt.intern("msg_out"), pmt_msg)
                  
                  return True
              except ValueError:
                  print(f"Error: Invalid Hex Address (Src: {self.node_id_hex}, Dst: {dst_hex})")
                  return False

          def handle_msg_in(self, pdu):
              try:
                  # Extract Payload
                  payload = bytes(pmt.to_python(pmt.cdr(pdu)))
                  
                  if len(payload) == 0:
                      return

                  msg_str = payload.decode('utf-8', errors='ignore')
                  if len(msg_str.strip()) == 0: return

                  # Extract Metadata
                  meta = pmt.to_python(pmt.car(pdu))
                  source_id = "UNKNOWN"
                  if isinstance(meta, dict) and 'src_id' in meta:
                      source_id = f"{meta['src_id']:02X}"
                  
                  self.gui.signal_rx_msg.emit(source_id, msg_str)
              except Exception:
                  pass

          def handle_feedback(self, pdu):
              try:
                  status = pmt.symbol_to_string(pmt.cdr(pdu))
                  is_success = "ACK" in status
                  self.gui.signal_ack.emit(is_success)
              except Exception:
                  self.gui.signal_ack.emit(False)

          def work(self, input_items, output_items):
              return 0

      # --- Standardized GUI Class ---
      class EchoWaveWindow(QtWidgets.QWidget):
          signal_rx_msg = QtCore.pyqtSignal(str, str)
          signal_ack = QtCore.pyqtSignal(bool)

          def __init__(self, block_ref, win_title, my_fixed_id):
              super().__init__()
              self.block = block_ref
              self.history = {} 
              self.current_chat_id = None 
              self.win_title = win_title
              self.my_id = my_fixed_id # This is now fixed/read-only
              
              self.signal_rx_msg.connect(self.on_receive_message)
              self.signal_ack.connect(self.on_ack_received)

              self.init_ui()

          def init_ui(self):
              self.setWindowTitle(f"EchoWave - {self.win_title}")
              self.resize(950, 650)
              self.setStyleSheet("font-family: Segoe UI, Arial; font-size: 14px;")
              
              main_layout = QtWidgets.QHBoxLayout(self)
              main_layout.setContentsMargins(0,0,0,0)
              main_layout.setSpacing(0)

              # Sidebar
              sidebar = QtWidgets.QWidget()
              sidebar.setFixedWidth(280)
              sidebar.setStyleSheet("background-color: #111b21; color: #e9edef; border-right: 1px solid #333;")
              sidebar_layout = QtWidgets.QVBoxLayout(sidebar)
              
              brand = QtWidgets.QLabel("EchoWave")
              brand.setStyleSheet("font-size: 24px; font-weight: bold; color: #00a884; margin: 15px 0;")
              sidebar_layout.addWidget(brand)

              # Connection Group
              conn_group = QtWidgets.QGroupBox("CONFIGURATION")
              conn_group.setStyleSheet("QGroupBox { border: 1px solid #333; margin-top: 10px; padding-top: 10px; font-weight: bold; color: #8696a0; }")
              conn_layout = QtWidgets.QVBoxLayout(conn_group)
              
              # Row 1: Read-Only ID Display
              row1 = QtWidgets.QHBoxLayout()
              row1.addWidget(QtWidgets.QLabel("NODE ID:"))
              self.id_display = QtWidgets.QLabel(self.my_id)
              self.id_display.setStyleSheet("font-weight: bold; color: #00a884; font-size: 16px;")
              row1.addWidget(self.id_display)
              conn_layout.addLayout(row1)

              # Row 2: Target Input
              row2 = QtWidgets.QHBoxLayout()
              row2.addWidget(QtWidgets.QLabel("TO ID:"))
              self.dst_addr_input = QtWidgets.QLineEdit()
              self.dst_addr_input.setMaxLength(2)
              self.dst_addr_input.setPlaceholderText("Hex (e.g. B1)")
              self.dst_addr_input.setStyleSheet("background: #2a3942; color: white; border: none; padding: 5px;")
              self.dst_addr_input.returnPressed.connect(self.manual_connect)
              row2.addWidget(self.dst_addr_input)
              conn_layout.addLayout(row2)

              self.connect_btn = QtWidgets.QPushButton("INIT LINK")
              self.connect_btn.setStyleSheet("background-color: #00a884; color: white; border-radius: 5px; padding: 8px; font-weight: bold;")
              self.connect_btn.clicked.connect(self.manual_connect)
              conn_layout.addWidget(self.connect_btn)
              
              sidebar_layout.addWidget(conn_group)
              
              # Contact List
              sidebar_layout.addWidget(QtWidgets.QLabel("Active Feeds:"))
              self.contact_list = QtWidgets.QListWidget()
              self.contact_list.setStyleSheet("background-color: transparent; border: none; color: #d1d7db;")
              self.contact_list.itemClicked.connect(self.switch_conversation_from_list)
              sidebar_layout.addWidget(self.contact_list)

              # Right Panel
              right_panel = QtWidgets.QWidget()
              right_panel.setStyleSheet("background-color: #0b141a;") 
              right_layout = QtWidgets.QVBoxLayout(right_panel)
              right_layout.setContentsMargins(0,0,0,0)

              # Header
              header = QtWidgets.QWidget()
              header.setStyleSheet("background-color: #202c33; padding: 10px;")
              header.setFixedHeight(60)
              h_layout = QtWidgets.QHBoxLayout(header)
              
              self.chat_title = QtWidgets.QLabel("Select a Link")
              self.chat_title.setStyleSheet("font-size: 16px; font-weight: bold; color: white; background: transparent;")
              
              self.clear_btn = QtWidgets.QPushButton("Clear History")
              self.clear_btn.setStyleSheet("color: #ef5350; background: transparent; border: 1px solid #ef5350; padding: 5px; border-radius: 4px;")
              self.clear_btn.clicked.connect(self.clear_current_history)
              
              h_layout.addWidget(self.chat_title)
              h_layout.addStretch()
              h_layout.addWidget(self.clear_btn)

              # Chat Area
              self.scroll_area = QtWidgets.QScrollArea()
              self.scroll_area.setWidgetResizable(True)
              self.scroll_area.setStyleSheet("border: none; background: transparent;")
              
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
              self.chat_layout.addStretch()
              self.scroll_area.setWidget(self.chat_container)

              # Input Area
              self.footer = QtWidgets.QWidget()
              self.footer.setStyleSheet("background-color: #202c33; padding: 10px;")
              self.footer.setVisible(False)
              f_layout = QtWidgets.QHBoxLayout(self.footer)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message")
              self.msg_input.setStyleSheet("background-color: #2a3942; color: white; border: none; padding: 12px; border-radius: 8px;")
              self.msg_input.returnPressed.connect(self.send_message)
              
              self.send_btn = QtWidgets.QPushButton("➤")
              self.send_btn.setFixedSize(45, 40)
              self.send_btn.setStyleSheet("background-color: #00a884; color: white; border-radius: 8px; font-size: 18px;")
              self.send_btn.clicked.connect(self.send_message)
              
              f_layout.addWidget(self.msg_input)
              f_layout.addWidget(self.send_btn)

              right_layout.addWidget(header)
              right_layout.addWidget(self.scroll_area)
              right_layout.addWidget(self.footer)

              main_layout.addWidget(sidebar)
              main_layout.addWidget(right_panel)

          def manual_connect(self):
              target = self.dst_addr_input.text().strip().upper()
              if len(target) > 0:
                  if len(target) > 2: target = target[:2]
                  self.open_conversation(target)

          def open_conversation(self, target_id):
              self.current_chat_id = target_id
              self.chat_title.setText(f"Feed: {target_id}")
              self.footer.setVisible(True)
              self.ensure_contact_exists(target_id)
              self.render_history(target_id)

          def ensure_contact_exists(self, addr):
              items = [self.contact_list.item(i).text() for i in range(self.contact_list.count())]
              if addr not in items:
                  self.contact_list.addItem(addr)

          def switch_conversation_from_list(self, item):
              self.dst_addr_input.setText(item.text())
              self.open_conversation(item.text())

          def clear_current_history(self):
              if self.current_chat_id:
                  self.history[self.current_chat_id] = []
                  self.render_history(self.current_chat_id)

          def render_history(self, chat_id):
              while self.chat_layout.count() > 1:
                  item = self.chat_layout.takeAt(1)
                  if item.widget(): item.widget().deleteLater()
              
              msgs = self.history.get(chat_id, [])
              for m in msgs:
                  self.add_bubble(m['text'], m['is_sender'], m['time'], m['status'])

          def save_to_history(self, chat_id, text, is_sender, status=""):
              if chat_id not in self.history: self.history[chat_id] = []
              entry = {'text': text, 'is_sender': is_sender, 'time': datetime.datetime.now().strftime("%H:%M"), 'status': status}
              self.history[chat_id].append(entry)

          def send_message(self):
              text = self.msg_input.text().strip()
              dst = self.current_chat_id 
              if not text or not dst: return

              # SRC is now handled internally via self.block.node_id_hex
              if self.block.process_user_input(dst, text):
                  self.save_to_history(dst, text, True, "pending")
                  self.add_bubble(text, True, datetime.datetime.now().strftime("%H:%M"), "pending")
                  self.msg_input.clear()

          def on_receive_message(self, source, msg):
              self.save_to_history(source, msg, False)
              self.ensure_contact_exists(source)
              if source == self.current_chat_id:
                  self.add_bubble(msg, False, datetime.datetime.now().strftime("%H:%M"), "")

          def on_ack_received(self, success):
              if self.current_chat_id in self.history:
                  chat_log = self.history[self.current_chat_id]
                  for i in range(len(chat_log)-1, -1, -1):
                      if chat_log[i]['is_sender'] and chat_log[i]['status'] == "pending":
                          chat_log[i]['status'] = "success" if success else "fail"
                          self.render_history(self.current_chat_id)
                          break

          def add_bubble(self, text, is_sender, time, status):
              row = QtWidgets.QWidget()
              row.setStyleSheet("background: transparent;")
              layout = QtWidgets.QHBoxLayout(row)
              
              bubble = QtWidgets.QFrame()
              b_layout = QtWidgets.QVBoxLayout(bubble)
              
              if is_sender:
                  bubble.setStyleSheet("background-color: #005c4b; border-radius: 10px; margin-left: 50px;")
                  layout.addStretch()
                  layout.addWidget(bubble)
              else:
                  bubble.setStyleSheet("background-color: #202c33; border-radius: 10px; margin-right: 50px;")
                  layout.addWidget(bubble)
                  layout.addStretch()
                  
              lbl = QtWidgets.QLabel(text)
              lbl.setWordWrap(True)
              lbl.setStyleSheet("color: #e9edef; font-size: 14px; background: transparent; border: none;")
              b_layout.addWidget(lbl)
              
              meta = QtWidgets.QHBoxLayout()
              meta.addStretch()
              t_lbl = QtWidgets.QLabel(time)
              t_lbl.setStyleSheet("color: #8696a0; font-size: 11px; background: transparent; border: none;")
              meta.addWidget(t_lbl)
              
              if is_sender:
                  icon = "🕒"
                  color = "#8696a0"
                  if status == "success": 
                      icon = "✓✓"
                      color = "#53bdeb"
                  elif status == "fail": 
                      icon = "!"
                      color = "red"
                  
                  s_lbl = QtWidgets.QLabel(icon)
                  s_lbl.setStyleSheet(f"color: {color}; font-size: 11px; font-weight: bold; background: transparent; border: none;")
                  meta.addWidget(s_lbl)
                  
              b_layout.addLayout(meta)
              self.chat_layout.addWidget(row)
              QtCore.QTimer.singleShot(10, lambda: self.scroll_area.verticalScrollBar().setValue(self.scroll_area.verticalScrollBar().maximum()))
    node_id_hex: user_1
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: EchoWave Core (Fixed Source ID)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import sys
      import datetime
      from PyQt5 import QtWidgets, QtCore, QtGui

      class blk(gr.sync_block):
          def __init__(self, node_id_hex='A1'):
              """
              Args:
                  node_id_hex: The fixed 1-byte address for this node (Hex String, e.g., 'A1').
              """
              gr.sync_block.__init__(self,
                  name='EchoWave Core',
                  in_sig=None,
                  out_sig=None)

              self.node_id_hex = node_id_hex

              # Register Message Ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_in(pmt.intern("feedback_in"))
              self.message_port_register_out(pmt.intern("addr_out"))
              self.message_port_register_out(pmt.intern("msg_out"))

              # Register Handlers
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_in)
              self.set_msg_handler(pmt.intern("feedback_in"), self.handle_feedback)

              # Initialize GUI
              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)
              
              # Pass the fixed ID to the Window
              self.gui = EchoWaveWindow(self, f"Node {node_id_hex}", node_id_hex)
              self.gui.show()
              
              # Ghost Window Fix
              self.cleanup_timer = QtCore.QTimer()
              self.cleanup_timer.timeout.connect(self.hide_ghost_window)
              self.cleanup_timer.start(200)

          def hide_ghost_window(self):
              for w in QtWidgets.QApplication.topLevelWidgets():
                  if isinstance(w, QtWidgets.QMainWindow) and w != self.gui:
                      w.hide()
              self.cleanup_timer.stop()

          def process_user_input(self, dst_hex, text):
              """ 
              Process input from GUI.
              Source ID is now fixed from block param (self.node_id_hex).
              """
              try:
                  # Parse Hex to Int (0-255)
                  src_val = int(self.node_id_hex, 16) # Uses the fixed parameter
                  dst_val = int(dst_hex, 16)
                  
                  # 1. Address PDU: [Dest, Source]
                  addr_list = [dst_val, src_val]
                  pmt_addr = pmt.cons(pmt.make_dict(), pmt.init_u8vector(2, addr_list))
                  self.message_port_pub(pmt.intern("addr_out"), pmt_addr)
                  
                  # 2. Message PDU: UTF-8 Bytes
                  msg_bytes = [x for x in text.encode('utf-8')]
                  pmt_msg = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(msg_bytes), msg_bytes))
                  self.message_port_pub(pmt.intern("msg_out"), pmt_msg)
                  
                  return True
              except ValueError:
                  print(f"Error: Invalid Hex Address (Src: {self.node_id_hex}, Dst: {dst_hex})")
                  return False

          def handle_msg_in(self, pdu):
              try:
                  # Extract Payload
                  payload = bytes(pmt.to_python(pmt.cdr(pdu)))
                  
                  if len(payload) == 0:
                      return

                  msg_str = payload.decode('utf-8', errors='ignore')
                  if len(msg_str.strip()) == 0: return

                  # Extract Metadata
                  meta = pmt.to_python(pmt.car(pdu))
                  source_id = "UNKNOWN"
                  if isinstance(meta, dict) and 'src_id' in meta:
                      source_id = f"{meta['src_id']:02X}"
                  
                  self.gui.signal_rx_msg.emit(source_id, msg_str)
              except Exception:
                  pass

          def handle_feedback(self, pdu):
              try:
                  status = pmt.symbol_to_string(pmt.cdr(pdu))
                  is_success = "ACK" in status
                  self.gui.signal_ack.emit(is_success)
              except Exception:
                  self.gui.signal_ack.emit(False)

          def work(self, input_items, output_items):
              return 0

      # --- Standardized GUI Class ---
      class EchoWaveWindow(QtWidgets.QWidget):
          signal_rx_msg = QtCore.pyqtSignal(str, str)
          signal_ack = QtCore.pyqtSignal(bool)

          def __init__(self, block_ref, win_title, my_fixed_id):
              super().__init__()
              self.block = block_ref
              self.history = {} 
              self.current_chat_id = None 
              self.win_title = win_title
              self.my_id = my_fixed_id # This is now fixed/read-only
              
              self.signal_rx_msg.connect(self.on_receive_message)
              self.signal_ack.connect(self.on_ack_received)

              self.init_ui()

          def init_ui(self):
              self.setWindowTitle(f"EchoWave - {self.win_title}")
              self.resize(950, 650)
              self.setStyleSheet("font-family: Segoe UI, Arial; font-size: 14px;")
              
              main_layout = QtWidgets.QHBoxLayout(self)
              main_layout.setContentsMargins(0,0,0,0)
              main_layout.setSpacing(0)

              # Sidebar
              sidebar = QtWidgets.QWidget()
              sidebar.setFixedWidth(280)
              sidebar.setStyleSheet("background-color: #111b21; color: #e9edef; border-right: 1px solid #333;")
              sidebar_layout = QtWidgets.QVBoxLayout(sidebar)
              
              brand = QtWidgets.QLabel("EchoWave")
              brand.setStyleSheet("font-size: 24px; font-weight: bold; color: #00a884; margin: 15px 0;")
              sidebar_layout.addWidget(brand)

              # Connection Group
              conn_group = QtWidgets.QGroupBox("CONFIGURATION")
              conn_group.setStyleSheet("QGroupBox { border: 1px solid #333; margin-top: 10px; padding-top: 10px; font-weight: bold; color: #8696a0; }")
              conn_layout = QtWidgets.QVBoxLayout(conn_group)
              
              # Row 1: Read-Only ID Display
              row1 = QtWidgets.QHBoxLayout()
              row1.addWidget(QtWidgets.QLabel("NODE ID:"))
              self.id_display = QtWidgets.QLabel(self.my_id)
              self.id_display.setStyleSheet("font-weight: bold; color: #00a884; font-size: 16px;")
              row1.addWidget(self.id_display)
              conn_layout.addLayout(row1)

              # Row 2: Target Input
              row2 = QtWidgets.QHBoxLayout()
              row2.addWidget(QtWidgets.QLabel("TO ID:"))
              self.dst_addr_input = QtWidgets.QLineEdit()
              self.dst_addr_input.setMaxLength(2)
              self.dst_addr_input.setPlaceholderText("Hex (e.g. B1)")
              self.dst_addr_input.setStyleSheet("background: #2a3942; color: white; border: none; padding: 5px;")
              self.dst_addr_input.returnPressed.connect(self.manual_connect)
              row2.addWidget(self.dst_addr_input)
              conn_layout.addLayout(row2)

              self.connect_btn = QtWidgets.QPushButton("INIT LINK")
              self.connect_btn.setStyleSheet("background-color: #00a884; color: white; border-radius: 5px; padding: 8px; font-weight: bold;")
              self.connect_btn.clicked.connect(self.manual_connect)
              conn_layout.addWidget(self.connect_btn)
              
              sidebar_layout.addWidget(conn_group)
              
              # Contact List
              sidebar_layout.addWidget(QtWidgets.QLabel("Active Feeds:"))
              self.contact_list = QtWidgets.QListWidget()
              self.contact_list.setStyleSheet("background-color: transparent; border: none; color: #d1d7db;")
              self.contact_list.itemClicked.connect(self.switch_conversation_from_list)
              sidebar_layout.addWidget(self.contact_list)

              # Right Panel
              right_panel = QtWidgets.QWidget()
              right_panel.setStyleSheet("background-color: #0b141a;") 
              right_layout = QtWidgets.QVBoxLayout(right_panel)
              right_layout.setContentsMargins(0,0,0,0)

              # Header
              header = QtWidgets.QWidget()
              header.setStyleSheet("background-color: #202c33; padding: 10px;")
              header.setFixedHeight(60)
              h_layout = QtWidgets.QHBoxLayout(header)
              
              self.chat_title = QtWidgets.QLabel("Select a Link")
              self.chat_title.setStyleSheet("font-size: 16px; font-weight: bold; color: white; background: transparent;")
              
              self.clear_btn = QtWidgets.QPushButton("Clear History")
              self.clear_btn.setStyleSheet("color: #ef5350; background: transparent; border: 1px solid #ef5350; padding: 5px; border-radius: 4px;")
              self.clear_btn.clicked.connect(self.clear_current_history)
              
              h_layout.addWidget(self.chat_title)
              h_layout.addStretch()
              h_layout.addWidget(self.clear_btn)

              # Chat Area
              self.scroll_area = QtWidgets.QScrollArea()
              self.scroll_area.setWidgetResizable(True)
              self.scroll_area.setStyleSheet("border: none; background: transparent;")
              
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
              self.chat_layout.addStretch()
              self.scroll_area.setWidget(self.chat_container)

              # Input Area
              self.footer = QtWidgets.QWidget()
              self.footer.setStyleSheet("background-color: #202c33; padding: 10px;")
              self.footer.setVisible(False)
              f_layout = QtWidgets.QHBoxLayout(self.footer)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message")
              self.msg_input.setStyleSheet("background-color: #2a3942; color: white; border: none; padding: 12px; border-radius: 8px;")
              self.msg_input.returnPressed.connect(self.send_message)
              
              self.send_btn = QtWidgets.QPushButton("➤")
              self.send_btn.setFixedSize(45, 40)
              self.send_btn.setStyleSheet("background-color: #00a884; color: white; border-radius: 8px; font-size: 18px;")
              self.send_btn.clicked.connect(self.send_message)
              
              f_layout.addWidget(self.msg_input)
              f_layout.addWidget(self.send_btn)

              right_layout.addWidget(header)
              right_layout.addWidget(self.scroll_area)
              right_layout.addWidget(self.footer)

              main_layout.addWidget(sidebar)
              main_layout.addWidget(right_panel)

          def manual_connect(self):
              target = self.dst_addr_input.text().strip().upper()
              if len(target) > 0:
                  if len(target) > 2: target = target[:2]
                  self.open_conversation(target)

          def open_conversation(self, target_id):
              self.current_chat_id = target_id
              self.chat_title.setText(f"Feed: {target_id}")
              self.footer.setVisible(True)
              self.ensure_contact_exists(target_id)
              self.render_history(target_id)

          def ensure_contact_exists(self, addr):
              items = [self.contact_list.item(i).text() for i in range(self.contact_list.count())]
              if addr not in items:
                  self.contact_list.addItem(addr)

          def switch_conversation_from_list(self, item):
              self.dst_addr_input.setText(item.text())
              self.open_conversation(item.text())

          def clear_current_history(self):
              if self.current_chat_id:
                  self.history[self.current_chat_id] = []
                  self.render_history(self.current_chat_id)

          def render_history(self, chat_id):
              while self.chat_layout.count() > 1:
                  item = self.chat_layout.takeAt(1)
                  if item.widget(): item.widget().deleteLater()
              
              msgs = self.history.get(chat_id, [])
              for m in msgs:
                  self.add_bubble(m['text'], m['is_sender'], m['time'], m['status'])

          def save_to_history(self, chat_id, text, is_sender, status=""):
              if chat_id not in self.history: self.history[chat_id] = []
              entry = {'text': text, 'is_sender': is_sender, 'time': datetime.datetime.now().strftime("%H:%M"), 'status': status}
              self.history[chat_id].append(entry)

          def send_message(self):
              text = self.msg_input.text().strip()
              dst = self.current_chat_id 
              if not text or not dst: return

              # SRC is now handled internally via self.block.node_id_hex
              if self.block.process_user_input(dst, text):
                  self.save_to_history(dst, text, True, "pending")
                  self.add_bubble(text, True, datetime.datetime.now().strftime("%H:%M"), "pending")
                  self.msg_input.clear()

          def on_receive_message(self, source, msg):
              self.save_to_history(source, msg, False)
              self.ensure_contact_exists(source)
              if source == self.current_chat_id:
                  self.add_bubble(msg, False, datetime.datetime.now().strftime("%H:%M"), "")

          def on_ack_received(self, success):
              if self.current_chat_id in self.history:
                  chat_log = self.history[self.current_chat_id]
                  for i in range(len(chat_log)-1, -1, -1):
                      if chat_log[i]['is_sender'] and chat_log[i]['status'] == "pending":
                          chat_log[i]['status'] = "success" if success else "fail"
                          self.render_history(self.current_chat_id)
                          break

          def add_bubble(self, text, is_sender, time, status):
              row = QtWidgets.QWidget()
              row.setStyleSheet("background: transparent;")
              layout = QtWidgets.QHBoxLayout(row)
              
              bubble = QtWidgets.QFrame()
              b_layout = QtWidgets.QVBoxLayout(bubble)
              
              if is_sender:
                  bubble.setStyleSheet("background-color: #005c4b; border-radius: 10px; margin-left: 50px;")
                  layout.addStretch()
                  layout.addWidget(bubble)
              else:
                  bubble.setStyleSheet("background-color: #202c33; border-radius: 10px; margin-right: 50px;")
                  layout.addWidget(bubble)
                  layout.addStretch()
                  
              lbl = QtWidgets.QLabel(text)
              lbl.setWordWrap(True)
              lbl.setStyleSheet("color: #e9edef; font-size: 14px; background: transparent; border: none;")
              b_layout.addWidget(lbl)
              
              meta = QtWidgets.QHBoxLayout()
              meta.addStretch()
              t_lbl = QtWidgets.QLabel(time)
              t_lbl.setStyleSheet("color: #8696a0; font-size: 11px; background: transparent; border: none;")
              meta.addWidget(t_lbl)
              
              if is_sender:
                  icon = "🕒"
                  color = "#8696a0"
                  if status == "success": 
                      icon = "✓✓"
                      color = "#53bdeb"
                  elif status == "fail": 
                      icon = "!"
                      color = "red"
                  
                  s_lbl = QtWidgets.QLabel(icon)
                  s_lbl.setStyleSheet(f"color: {color}; font-size: 11px; font-weight: bold; background: transparent; border: none;")
                  meta.addWidget(s_lbl)
                  
              b_layout.addLayout(meta)
              self.chat_layout.addWidget(row)
              QtCore.QTimer.singleShot(10, lambda: self.scroll_area.verticalScrollBar().setValue(self.scroll_area.verticalScrollBar().maximum()))
    node_id_hex: user_2
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: EchoWave Core (Fixed Source ID)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import sys
      import datetime
      from PyQt5 import QtWidgets, QtCore, QtGui

      class blk(gr.sync_block):
          def __init__(self, node_id_hex='A1'):
              """
              Args:
                  node_id_hex: The fixed 1-byte address for this node (Hex String, e.g., 'A1').
              """
              gr.sync_block.__init__(self,
                  name='EchoWave Core',
                  in_sig=None,
                  out_sig=None)

              self.node_id_hex = node_id_hex

              # Register Message Ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_in(pmt.intern("feedback_in"))
              self.message_port_register_out(pmt.intern("addr_out"))
              self.message_port_register_out(pmt.intern("msg_out"))

              # Register Handlers
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg_in)
              self.set_msg_handler(pmt.intern("feedback_in"), self.handle_feedback)

              # Initialize GUI
              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)
              
              # Pass the fixed ID to the Window
              self.gui = EchoWaveWindow(self, f"Node {node_id_hex}", node_id_hex)
              self.gui.show()
              
              # Ghost Window Fix
              self.cleanup_timer = QtCore.QTimer()
              self.cleanup_timer.timeout.connect(self.hide_ghost_window)
              self.cleanup_timer.start(200)

          def hide_ghost_window(self):
              for w in QtWidgets.QApplication.topLevelWidgets():
                  if isinstance(w, QtWidgets.QMainWindow) and w != self.gui:
                      w.hide()
              self.cleanup_timer.stop()

          def process_user_input(self, dst_hex, text):
              """ 
              Process input from GUI.
              Source ID is now fixed from block param (self.node_id_hex).
              """
              try:
                  # Parse Hex to Int (0-255)
                  src_val = int(self.node_id_hex, 16) # Uses the fixed parameter
                  dst_val = int(dst_hex, 16)
                  
                  # 1. Address PDU: [Dest, Source]
                  addr_list = [dst_val, src_val]
                  pmt_addr = pmt.cons(pmt.make_dict(), pmt.init_u8vector(2, addr_list))
                  self.message_port_pub(pmt.intern("addr_out"), pmt_addr)
                  
                  # 2. Message PDU: UTF-8 Bytes
                  msg_bytes = [x for x in text.encode('utf-8')]
                  pmt_msg = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(msg_bytes), msg_bytes))
                  self.message_port_pub(pmt.intern("msg_out"), pmt_msg)
                  
                  return True
              except ValueError:
                  print(f"Error: Invalid Hex Address (Src: {self.node_id_hex}, Dst: {dst_hex})")
                  return False

          def handle_msg_in(self, pdu):
              try:
                  # Extract Payload
                  payload = bytes(pmt.to_python(pmt.cdr(pdu)))
                  
                  if len(payload) == 0:
                      return

                  msg_str = payload.decode('utf-8', errors='ignore')
                  if len(msg_str.strip()) == 0: return

                  # Extract Metadata
                  meta = pmt.to_python(pmt.car(pdu))
                  source_id = "UNKNOWN"
                  if isinstance(meta, dict) and 'src_id' in meta:
                      source_id = f"{meta['src_id']:02X}"
                  
                  self.gui.signal_rx_msg.emit(source_id, msg_str)
              except Exception:
                  pass

          def handle_feedback(self, pdu):
              try:
                  status = pmt.symbol_to_string(pmt.cdr(pdu))
                  is_success = "ACK" in status
                  self.gui.signal_ack.emit(is_success)
              except Exception:
                  self.gui.signal_ack.emit(False)

          def work(self, input_items, output_items):
              return 0

      # --- Standardized GUI Class ---
      class EchoWaveWindow(QtWidgets.QWidget):
          signal_rx_msg = QtCore.pyqtSignal(str, str)
          signal_ack = QtCore.pyqtSignal(bool)

          def __init__(self, block_ref, win_title, my_fixed_id):
              super().__init__()
              self.block = block_ref
              self.history = {} 
              self.current_chat_id = None 
              self.win_title = win_title
              self.my_id = my_fixed_id # This is now fixed/read-only
              
              self.signal_rx_msg.connect(self.on_receive_message)
              self.signal_ack.connect(self.on_ack_received)

              self.init_ui()

          def init_ui(self):
              self.setWindowTitle(f"EchoWave - {self.win_title}")
              self.resize(950, 650)
              self.setStyleSheet("font-family: Segoe UI, Arial; font-size: 14px;")
              
              main_layout = QtWidgets.QHBoxLayout(self)
              main_layout.setContentsMargins(0,0,0,0)
              main_layout.setSpacing(0)

              # Sidebar
              sidebar = QtWidgets.QWidget()
              sidebar.setFixedWidth(280)
              sidebar.setStyleSheet("background-color: #111b21; color: #e9edef; border-right: 1px solid #333;")
              sidebar_layout = QtWidgets.QVBoxLayout(sidebar)
              
              brand = QtWidgets.QLabel("EchoWave")
              brand.setStyleSheet("font-size: 24px; font-weight: bold; color: #00a884; margin: 15px 0;")
              sidebar_layout.addWidget(brand)

              # Connection Group
              conn_group = QtWidgets.QGroupBox("CONFIGURATION")
              conn_group.setStyleSheet("QGroupBox { border: 1px solid #333; margin-top: 10px; padding-top: 10px; font-weight: bold; color: #8696a0; }")
              conn_layout = QtWidgets.QVBoxLayout(conn_group)
              
              # Row 1: Read-Only ID Display
              row1 = QtWidgets.QHBoxLayout()
              row1.addWidget(QtWidgets.QLabel("NODE ID:"))
              self.id_display = QtWidgets.QLabel(self.my_id)
              self.id_display.setStyleSheet("font-weight: bold; color: #00a884; font-size: 16px;")
              row1.addWidget(self.id_display)
              conn_layout.addLayout(row1)

              # Row 2: Target Input
              row2 = QtWidgets.QHBoxLayout()
              row2.addWidget(QtWidgets.QLabel("TO ID:"))
              self.dst_addr_input = QtWidgets.QLineEdit()
              self.dst_addr_input.setMaxLength(2)
              self.dst_addr_input.setPlaceholderText("Hex (e.g. B1)")
              self.dst_addr_input.setStyleSheet("background: #2a3942; color: white; border: none; padding: 5px;")
              self.dst_addr_input.returnPressed.connect(self.manual_connect)
              row2.addWidget(self.dst_addr_input)
              conn_layout.addLayout(row2)

              self.connect_btn = QtWidgets.QPushButton("INIT LINK")
              self.connect_btn.setStyleSheet("background-color: #00a884; color: white; border-radius: 5px; padding: 8px; font-weight: bold;")
              self.connect_btn.clicked.connect(self.manual_connect)
              conn_layout.addWidget(self.connect_btn)
              
              sidebar_layout.addWidget(conn_group)
              
              # Contact List
              sidebar_layout.addWidget(QtWidgets.QLabel("Active Feeds:"))
              self.contact_list = QtWidgets.QListWidget()
              self.contact_list.setStyleSheet("background-color: transparent; border: none; color: #d1d7db;")
              self.contact_list.itemClicked.connect(self.switch_conversation_from_list)
              sidebar_layout.addWidget(self.contact_list)

              # Right Panel
              right_panel = QtWidgets.QWidget()
              right_panel.setStyleSheet("background-color: #0b141a;") 
              right_layout = QtWidgets.QVBoxLayout(right_panel)
              right_layout.setContentsMargins(0,0,0,0)

              # Header
              header = QtWidgets.QWidget()
              header.setStyleSheet("background-color: #202c33; padding: 10px;")
              header.setFixedHeight(60)
              h_layout = QtWidgets.QHBoxLayout(header)
              
              self.chat_title = QtWidgets.QLabel("Select a Link")
              self.chat_title.setStyleSheet("font-size: 16px; font-weight: bold; color: white; background: transparent;")
              
              self.clear_btn = QtWidgets.QPushButton("Clear History")
              self.clear_btn.setStyleSheet("color: #ef5350; background: transparent; border: 1px solid #ef5350; padding: 5px; border-radius: 4px;")
              self.clear_btn.clicked.connect(self.clear_current_history)
              
              h_layout.addWidget(self.chat_title)
              h_layout.addStretch()
              h_layout.addWidget(self.clear_btn)

              # Chat Area
              self.scroll_area = QtWidgets.QScrollArea()
              self.scroll_area.setWidgetResizable(True)
              self.scroll_area.setStyleSheet("border: none; background: transparent;")
              
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
              self.chat_layout.addStretch()
              self.scroll_area.setWidget(self.chat_container)

              # Input Area
              self.footer = QtWidgets.QWidget()
              self.footer.setStyleSheet("background-color: #202c33; padding: 10px;")
              self.footer.setVisible(False)
              f_layout = QtWidgets.QHBoxLayout(self.footer)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message")
              self.msg_input.setStyleSheet("background-color: #2a3942; color: white; border: none; padding: 12px; border-radius: 8px;")
              self.msg_input.returnPressed.connect(self.send_message)
              
              self.send_btn = QtWidgets.QPushButton("➤")
              self.send_btn.setFixedSize(45, 40)
              self.send_btn.setStyleSheet("background-color: #00a884; color: white; border-radius: 8px; font-size: 18px;")
              self.send_btn.clicked.connect(self.send_message)
              
              f_layout.addWidget(self.msg_input)
              f_layout.addWidget(self.send_btn)

              right_layout.addWidget(header)
              right_layout.addWidget(self.scroll_area)
              right_layout.addWidget(self.footer)

              main_layout.addWidget(sidebar)
              main_layout.addWidget(right_panel)

          def manual_connect(self):
              target = self.dst_addr_input.text().strip().upper()
              if len(target) > 0:
                  if len(target) > 2: target = target[:2]
                  self.open_conversation(target)

          def open_conversation(self, target_id):
              self.current_chat_id = target_id
              self.chat_title.setText(f"Feed: {target_id}")
              self.footer.setVisible(True)
              self.ensure_contact_exists(target_id)
              self.render_history(target_id)

          def ensure_contact_exists(self, addr):
              items = [self.contact_list.item(i).text() for i in range(self.contact_list.count())]
              if addr not in items:
                  self.contact_list.addItem(addr)

          def switch_conversation_from_list(self, item):
              self.dst_addr_input.setText(item.text())
              self.open_conversation(item.text())

          def clear_current_history(self):
              if self.current_chat_id:
                  self.history[self.current_chat_id] = []
                  self.render_history(self.current_chat_id)

          def render_history(self, chat_id):
              while self.chat_layout.count() > 1:
                  item = self.chat_layout.takeAt(1)
                  if item.widget(): item.widget().deleteLater()
              
              msgs = self.history.get(chat_id, [])
              for m in msgs:
                  self.add_bubble(m['text'], m['is_sender'], m['time'], m['status'])

          def save_to_history(self, chat_id, text, is_sender, status=""):
              if chat_id not in self.history: self.history[chat_id] = []
              entry = {'text': text, 'is_sender': is_sender, 'time': datetime.datetime.now().strftime("%H:%M"), 'status': status}
              self.history[chat_id].append(entry)

          def send_message(self):
              text = self.msg_input.text().strip()
              dst = self.current_chat_id 
              if not text or not dst: return

              # SRC is now handled internally via self.block.node_id_hex
              if self.block.process_user_input(dst, text):
                  self.save_to_history(dst, text, True, "pending")
                  self.add_bubble(text, True, datetime.datetime.now().strftime("%H:%M"), "pending")
                  self.msg_input.clear()

          def on_receive_message(self, source, msg):
              self.save_to_history(source, msg, False)
              self.ensure_contact_exists(source)
              if source == self.current_chat_id:
                  self.add_bubble(msg, False, datetime.datetime.now().strftime("%H:%M"), "")

          def on_ack_received(self, success):
              if self.current_chat_id in self.history:
                  chat_log = self.history[self.current_chat_id]
                  for i in range(len(chat_log)-1, -1, -1):
                      if chat_log[i]['is_sender'] and chat_log[i]['status'] == "pending":
                          chat_log[i]['status'] = "success" if success else "fail"
                          self.render_history(self.current_chat_id)
                          break

          def add_bubble(self, text, is_sender, time, status):
              row = QtWidgets.QWidget()
              row.setStyleSheet("background: transparent;")
              layout = QtWidgets.QHBoxLayout(row)
              
              bubble = QtWidgets.QFrame()
              b_layout = QtWidgets.QVBoxLayout(bubble)
              
              if is_sender:
                  bubble.setStyleSheet("background-color: #005c4b; border-radius: 10px; margin-left: 50px;")
                  layout.addStretch()
                  layout.addWidget(bubble)
              else:
                  bubble.setStyleSheet("background-color: #202c33; border-radius: 10px; margin-right: 50px;")
                  layout.addWidget(bubble)
                  layout.addStretch()
                  
              lbl = QtWidgets.QLabel(text)
              lbl.setWordWrap(True)
              lbl.setStyleSheet("color: #e9edef; font-size: 14px; background: transparent; border: none;")
              b_layout.addWidget(lbl)
              
              meta = QtWidgets.QHBoxLayout()
              meta.addStretch()
              t_lbl = QtWidgets.QLabel(time)
              t_lbl.setStyleSheet("color: #8696a0; font-size: 11px; background: transparent; border: none;")
              meta.addWidget(t_lbl)
              
              if is_sender:
                  icon = "🕒"
                  color = "#8696a0"
                  if status == "success": 
                      icon = "✓✓"
                      color = "#53bdeb"
                  elif status == "fail": 
                      icon = "!"
                      color = "red"
                  
                  s_lbl = QtWidgets.QLabel(icon)
                  s_lbl.setStyleSheet(f"color: {color}; font-size: 11px; font-weight: bold; background: transparent; border: none;")
                  meta.addWidget(s_lbl)
                  
              b_layout.addLayout(meta)
              self.chat_layout.addWidget(row)
              QtCore.QTimer.singleShot(10, lambda: self.scroll_area.verticalScrollBar().setValue(self.scroll_area.verticalScrollBar().maximum()))
    node_id_hex: user_3
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: PDU Prepend Dummy Bytes
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=64):  # Default to 64 bytes
              """
              Constructor.
              Args:
                  num_dummy_bytes: The number of random bytes to prepend.
              """
              gr.basic_block.__init__(
                  self,
                  name='PDU Prepend Dummy Bytes',
                  in_sig=None,
                  out_sig=None
              )
              
              # Save the parameter
              self.num_dummy_bytes = num_dummy_bytes

              # Register message ports for PDU handling
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set up the message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              """
              Message handler that processes incoming PDUs.
              """
              # 1. Validate that the message is a PDU (it should be a pair: meta + data)
              if not pmt.is_pair(msg):
                  return

              # 2. Extract metadata and data vector
              meta = pmt.car(msg)
              data_pmt = pmt.cdr(msg)
              
              # Convert PMT vector to a numpy array (uint8)
              # We rely on pmt.u8vector_elements to get the data out
              try:
                  input_data = pmt.u8vector_elements(data_pmt)
              except:
                  # If data is not a u8vector, ignore or print error
                  return

              # 3. Generate dummy bytes for QPSK Costas Loop Sync
              # We use random integers between 0 and 255.
              # Random data ensures White Noise properties, meaning we have an equal 
              # probability of generating 00, 01, 10, and 11 bit pairs.
              # This guarantees that the transitions hit all 4 points of the QPSK 
              # constellation (1+j, 1-j, -1+j, -1-j) to energize the loop.
              dummy_data = np.random.randint(0, 256, self.num_dummy_bytes, dtype=np.uint8)
              
              # 4. Concatenate the dummy bytes with the input data
              # input_data comes out as a tuple or list from pmt, convert to array first
              combined_data = np.concatenate((dummy_data, np.array(input_data, dtype=np.uint8)))

              # 5. Create new output PMT
              # We keep the original metadata (meta)
              out_len = len(combined_data)
              out_vector = pmt.init_u8vector(out_len, combined_data)
              out_msg = pmt.cons(meta, out_vector)

              # 6. Publish the message to the output port
              self.message_port_pub(pmt.intern('pdu_out'), out_msg)
    num_dummy_bytes: '100'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: PDU Prepend Dummy Bytes
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=64):  # Default to 64 bytes
              """
              Constructor.
              Args:
                  num_dummy_bytes: The number of random bytes to prepend.
              """
              gr.basic_block.__init__(
                  self,
                  name='PDU Prepend Dummy Bytes',
                  in_sig=None,
                  out_sig=None
              )
              
              # Save the parameter
              self.num_dummy_bytes = num_dummy_bytes

              # Register message ports for PDU handling
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set up the message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              """
              Message handler that processes incoming PDUs.
              """
              # 1. Validate that the message is a PDU (it should be a pair: meta + data)
              if not pmt.is_pair(msg):
                  return

              # 2. Extract metadata and data vector
              meta = pmt.car(msg)
              data_pmt = pmt.cdr(msg)
              
              # Convert PMT vector to a numpy array (uint8)
              # We rely on pmt.u8vector_elements to get the data out
              try:
                  input_data = pmt.u8vector_elements(data_pmt)
              except:
                  # If data is not a u8vector, ignore or print error
                  return

              # 3. Generate dummy bytes for QPSK Costas Loop Sync
              # We use random integers between 0 and 255.
              # Random data ensures White Noise properties, meaning we have an equal 
              # probability of generating 00, 01, 10, and 11 bit pairs.
              # This guarantees that the transitions hit all 4 points of the QPSK 
              # constellation (1+j, 1-j, -1+j, -1-j) to energize the loop.
              dummy_data = np.random.randint(0, 256, self.num_dummy_bytes, dtype=np.uint8)
              
              # 4. Concatenate the dummy bytes with the input data
              # input_data comes out as a tuple or list from pmt, convert to array first
              combined_data = np.concatenate((dummy_data, np.array(input_data, dtype=np.uint8)))

              # 5. Create new output PMT
              # We keep the original metadata (meta)
              out_len = len(combined_data)
              out_vector = pmt.init_u8vector(out_len, combined_data)
              out_msg = pmt.cons(meta, out_vector)

              # 6. Publish the message to the output port
              self.message_port_pub(pmt.intern('pdu_out'), out_msg)
    num_dummy_bytes: '100'
  states: {}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: PDU Prepend Dummy Bytes
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, num_dummy_bytes=64):  # Default to 64 bytes
              """
              Constructor.
              Args:
                  num_dummy_bytes: The number of random bytes to prepend.
              """
              gr.basic_block.__init__(
                  self,
                  name='PDU Prepend Dummy Bytes',
                  in_sig=None,
                  out_sig=None
              )
              
              # Save the parameter
              self.num_dummy_bytes = num_dummy_bytes

              # Register message ports for PDU handling
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set up the message handler
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              """
              Message handler that processes incoming PDUs.
              """
              # 1. Validate that the message is a PDU (it should be a pair: meta + data)
              if not pmt.is_pair(msg):
                  return

              # 2. Extract metadata and data vector
              meta = pmt.car(msg)
              data_pmt = pmt.cdr(msg)
              
              # Convert PMT vector to a numpy array (uint8)
              # We rely on pmt.u8vector_elements to get the data out
              try:
                  input_data = pmt.u8vector_elements(data_pmt)
              except:
                  # If data is not a u8vector, ignore or print error
                  return

              # 3. Generate dummy bytes for QPSK Costas Loop Sync
              # We use random integers between 0 and 255.
              # Random data ensures White Noise properties, meaning we have an equal 
              # probability of generating 00, 01, 10, and 11 bit pairs.
              # This guarantees that the transitions hit all 4 points of the QPSK 
              # constellation (1+j, 1-j, -1+j, -1-j) to energize the loop.
              dummy_data = np.random.randint(0, 256, self.num_dummy_bytes, dtype=np.uint8)
              
              # 4. Concatenate the dummy bytes with the input data
              # input_data comes out as a tuple or list from pmt, convert to array first
              combined_data = np.concatenate((dummy_data, np.array(input_data, dtype=np.uint8)))

              # 5. Create new output PMT
              # We keep the original metadata (meta)
              out_len = len(combined_data)
              out_vector = pmt.init_u8vector(out_len, combined_data)
              out_msg = pmt.cons(meta, out_vector)

              # 6. Publish the message to the output port
              self.message_port_pub(pmt.intern('pdu_out'), out_msg)
    num_dummy_bytes: '100'
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Receiver (Reads Length)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class blk(gr.basic_block):
          def __init__(self, my_addr_hex='A1'):
              gr.basic_block.__init__(self, name='Receiver / ACK Generator', in_sig=None, out_sig=None)
              
              try:
                  self.my_addr = int(my_addr_hex, 16)
              except ValueError:
                  self.my_addr = 0xA1
              
              self.reassembly_buffer = {}
              self.expected_seq = {} 

              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_out(pmt.intern('ack_out'))
              self.message_port_register_out(pmt.intern('ack_reply_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg): return
              full_packet = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # Header is now 7 bytes >BBBHBB
              if len(full_packet) < 7: return 

              try:
                  # Unpack 7 bytes: Dest, Src, Flag, Seq, Fin, LEN
                  dest, src, flag, seq, fin, data_len = struct.unpack('>BBBHBB', bytes(full_packet[:7]))
                  
                  # === CRITICAL FIX ===
                  # Only read 'data_len' bytes. Ignore everything else.
                  # If the buffer has 64 bytes but data_len is 5, we only take 5.
                  end_idx = 7 + data_len
                  if end_idx > len(full_packet): end_idx = len(full_packet)
                  
                  payload = full_packet[7 : end_idx]
              except:
                  return 

              if dest != self.my_addr: return

              if flag == 1:
                  self.message_port_pub(pmt.intern('ack_out'), msg)
                  return

              if src not in self.expected_seq:
                  self.expected_seq[src] = seq 
                  self.reassembly_buffer[src] = []

              expected = self.expected_seq[src]

              if seq == expected:
                  self.reassembly_buffer[src].append(bytes(payload))
                  self.expected_seq[src] = (expected + 1) & 0xFFFF
                  self.send_ack(src, self.expected_seq[src])
                  
                  if fin == 1:
                      self.push_to_gui(src)
                      
              elif seq < expected:
                  self.send_ack(src, expected)

          def send_ack(self, target_node, next_required_seq):
              # Header: Dest, Src, Flag=1, Seq, FIN=0, Len=0
              header = struct.pack('>BBBHBB', target_node, self.my_addr, 1, next_required_seq, 0, 0)
              out_pmt = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(header), list(header)))
              self.message_port_pub(pmt.intern('ack_reply_out'), out_pmt)

          def push_to_gui(self, src):
              try:
                  full_msg_bytes = b''.join(self.reassembly_buffer[src])
                  
                  # Now we don't need aggressive cleaning because we sliced the data perfectly.
                  # But standard decode is still good practice.
                  clean_bytes = list(full_msg_bytes)
                  
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src_id"), pmt.from_long(src))
                  
                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(clean_bytes), clean_bytes))
                  self.message_port_pub(pmt.intern('msg_out'), out_pmt)
                  
                  self.reassembly_buffer[src] = []
              except: pass
    my_addr_hex: user_1
  states: {}
- name: epy_block_4_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Receiver (Reads Length)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class blk(gr.basic_block):
          def __init__(self, my_addr_hex='A1'):
              gr.basic_block.__init__(self, name='Receiver / ACK Generator', in_sig=None, out_sig=None)
              
              try:
                  self.my_addr = int(my_addr_hex, 16)
              except ValueError:
                  self.my_addr = 0xA1
              
              self.reassembly_buffer = {}
              self.expected_seq = {} 

              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_out(pmt.intern('ack_out'))
              self.message_port_register_out(pmt.intern('ack_reply_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg): return
              full_packet = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # Header is now 7 bytes >BBBHBB
              if len(full_packet) < 7: return 

              try:
                  # Unpack 7 bytes: Dest, Src, Flag, Seq, Fin, LEN
                  dest, src, flag, seq, fin, data_len = struct.unpack('>BBBHBB', bytes(full_packet[:7]))
                  
                  # === CRITICAL FIX ===
                  # Only read 'data_len' bytes. Ignore everything else.
                  # If the buffer has 64 bytes but data_len is 5, we only take 5.
                  end_idx = 7 + data_len
                  if end_idx > len(full_packet): end_idx = len(full_packet)
                  
                  payload = full_packet[7 : end_idx]
              except:
                  return 

              if dest != self.my_addr: return

              if flag == 1:
                  self.message_port_pub(pmt.intern('ack_out'), msg)
                  return

              if src not in self.expected_seq:
                  self.expected_seq[src] = seq 
                  self.reassembly_buffer[src] = []

              expected = self.expected_seq[src]

              if seq == expected:
                  self.reassembly_buffer[src].append(bytes(payload))
                  self.expected_seq[src] = (expected + 1) & 0xFFFF
                  self.send_ack(src, self.expected_seq[src])
                  
                  if fin == 1:
                      self.push_to_gui(src)
                      
              elif seq < expected:
                  self.send_ack(src, expected)

          def send_ack(self, target_node, next_required_seq):
              # Header: Dest, Src, Flag=1, Seq, FIN=0, Len=0
              header = struct.pack('>BBBHBB', target_node, self.my_addr, 1, next_required_seq, 0, 0)
              out_pmt = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(header), list(header)))
              self.message_port_pub(pmt.intern('ack_reply_out'), out_pmt)

          def push_to_gui(self, src):
              try:
                  full_msg_bytes = b''.join(self.reassembly_buffer[src])
                  
                  # Now we don't need aggressive cleaning because we sliced the data perfectly.
                  # But standard decode is still good practice.
                  clean_bytes = list(full_msg_bytes)
                  
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src_id"), pmt.from_long(src))
                  
                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(clean_bytes), clean_bytes))
                  self.message_port_pub(pmt.intern('msg_out'), out_pmt)
                  
                  self.reassembly_buffer[src] = []
              except: pass
    my_addr_hex: user_2
  states: {}
- name: epy_block_4_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Receiver (Reads Length)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class blk(gr.basic_block):
          def __init__(self, my_addr_hex='A1'):
              gr.basic_block.__init__(self, name='Receiver / ACK Generator', in_sig=None, out_sig=None)
              
              try:
                  self.my_addr = int(my_addr_hex, 16)
              except ValueError:
                  self.my_addr = 0xA1
              
              self.reassembly_buffer = {}
              self.expected_seq = {} 

              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_out(pmt.intern('ack_out'))
              self.message_port_register_out(pmt.intern('ack_reply_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg): return
              full_packet = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # Header is now 7 bytes >BBBHBB
              if len(full_packet) < 7: return 

              try:
                  # Unpack 7 bytes: Dest, Src, Flag, Seq, Fin, LEN
                  dest, src, flag, seq, fin, data_len = struct.unpack('>BBBHBB', bytes(full_packet[:7]))
                  
                  # === CRITICAL FIX ===
                  # Only read 'data_len' bytes. Ignore everything else.
                  # If the buffer has 64 bytes but data_len is 5, we only take 5.
                  end_idx = 7 + data_len
                  if end_idx > len(full_packet): end_idx = len(full_packet)
                  
                  payload = full_packet[7 : end_idx]
              except:
                  return 

              if dest != self.my_addr: return

              if flag == 1:
                  self.message_port_pub(pmt.intern('ack_out'), msg)
                  return

              if src not in self.expected_seq:
                  self.expected_seq[src] = seq 
                  self.reassembly_buffer[src] = []

              expected = self.expected_seq[src]

              if seq == expected:
                  self.reassembly_buffer[src].append(bytes(payload))
                  self.expected_seq[src] = (expected + 1) & 0xFFFF
                  self.send_ack(src, self.expected_seq[src])
                  
                  if fin == 1:
                      self.push_to_gui(src)
                      
              elif seq < expected:
                  self.send_ack(src, expected)

          def send_ack(self, target_node, next_required_seq):
              # Header: Dest, Src, Flag=1, Seq, FIN=0, Len=0
              header = struct.pack('>BBBHBB', target_node, self.my_addr, 1, next_required_seq, 0, 0)
              out_pmt = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(header), list(header)))
              self.message_port_pub(pmt.intern('ack_reply_out'), out_pmt)

          def push_to_gui(self, src):
              try:
                  full_msg_bytes = b''.join(self.reassembly_buffer[src])
                  
                  # Now we don't need aggressive cleaning because we sliced the data perfectly.
                  # But standard decode is still good practice.
                  clean_bytes = list(full_msg_bytes)
                  
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src_id"), pmt.from_long(src))
                  
                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(clean_bytes), clean_bytes))
                  self.message_port_pub(pmt.intern('msg_out'), out_pmt)
                  
                  self.reassembly_buffer[src] = []
              except: pass
    my_addr_hex: user_3
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"RX constallation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"TX Constallation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"TX Constallation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"TX Constallation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"RX RAW"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"RX RAW"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0_1_1
  id: qtgui_const_sink_x
  parameters:
    name: '"RX RAW"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0_2
  id: qtgui_const_sink_x
  parameters:
    name: '"RX constallation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_3
  id: qtgui_const_sink_x
  parameters:
    name: '"RX constallation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    name: '"TX spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    name: '"RX spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    name: '"RX spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    name: '"RX spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    name: '"TX spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    name: '"TX spectrum"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"I am quite hungry"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"I am quite hungry"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"I am quite hungry"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_1
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 1.2e6
    center_freq: freq
    dev_args: driver=bladerf,gain_mode=manual,lna=max,vga1=20,vga2=20
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_1_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 1.2e6
    center_freq: freq
    dev_args: driver=bladerf,gain_mode=manual,lna=max,vga1=20,vga2=20
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_1_1
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 1.2e6
    center_freq: freq
    dev_args: driver=bladerf,gain_mode=manual,lna=max,vga1=20,vga2=20
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 1.2e6
    center_freq: freq
    dev_args: driver=bladerf,gain_mode=manual,lna=max,vga1=20,vga2=20
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 1.2e6
    center_freq: freq
    dev_args: driver=bladerf,gain_mode=manual,lna=max,vga1=20,vga2=20
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_1
  id: soapy_bladerf_source
  parameters:
    bandwidth: 1.2e6
    center_freq: freq
    dev_args: driver=bladerf,gain_mode=manual,lna=max,vga1=20,vga2=20
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Channel_in
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Channel_out_1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Channel_out_2
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Channel_out_3
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: User 1 Transmitter RX
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: User 2 Transmitter RX
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: User 3 Transmitter RX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Channel_in
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Channel_in
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Channel_in
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Channel_out_1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Channel_out_2
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: User 1 Transmitter RX
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: User 2 Transmitter RX
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: User 3 Transmitter RX
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: Channel_out_3
  states: {}

connections:
- [blocks_add_xx_0, '0', channels_channel_model_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', soapy_bladerf_sink_1_1, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_1, '0', digital_correlate_access_code_xx_ts_0_0_1, '0']
- [blocks_repack_bits_bb_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_throttle2_0_1, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_1, '0', pdu_tagged_stream_to_pdu_0_0_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0_1, '0', pdu_tagged_stream_to_pdu_0_1, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0_1, '0', digital_constellation_modulator_0_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_1, '0', blocks_pack_k_bits_bb_0_0_1, '0']
- [channels_channel_model_0_1, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_1, '0', digital_diff_decoder_bb_0_0_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_const_sink_x_1_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [digital_constellation_modulator_0_0, '0', virtual_sink_1_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_constellation_modulator_0_1, '0', qtgui_const_sink_x_1_0_0_1, '0']
- [digital_constellation_modulator_0_1, '0', qtgui_freq_sink_x_0_2, '0']
- [digital_constellation_modulator_0_1, '0', virtual_sink_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_1, '0', blocks_repack_bits_bb_1_0_0_0_1, '0']
- [digital_correlate_access_code_xx_ts_0_0_1, '0', blocks_uchar_to_float_0_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_1_0_2, '0']
- [digital_costas_loop_cc_0_0_1, '0', digital_constellation_decoder_cb_0_0_1, '0']
- [digital_costas_loop_cc_0_0_1, '0', qtgui_const_sink_x_1_0_3, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_append_0_1, out, digital_protocol_formatter_async_0_1, in]
- [digital_crc_check_0_0, ok, virtual_sink_2, '0']
- [digital_crc_check_0_0_0, ok, virtual_sink_2_0, '0']
- [digital_crc_check_0_0_1, ok, virtual_sink_2_1, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_1, '0', digital_map_bb_0_0_1, '0']
- [digital_linear_equalizer_0_1_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0_1_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_linear_equalizer_0_1_0_1, '0', digital_costas_loop_cc_0_0_1, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_map_bb_0_0_1, '0', blocks_unpack_k_bits_bb_0_0_1, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_1_0, pdus]
- [digital_protocol_formatter_async_0_1, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_1, payload, pdu_pdu_to_tagged_stream_1_1, pdus]
- [digital_symbol_sync_xx_0_1_0, '0', digital_linear_equalizer_0_1_0, '0']
- [digital_symbol_sync_xx_0_1_0_0, '0', digital_linear_equalizer_0_1_0_0, '0']
- [digital_symbol_sync_xx_0_1_0_1, '0', digital_linear_equalizer_0_1_0_1, '0']
- [epy_block_0, feedback_out, epy_block_1, feedback_in]
- [epy_block_0, packet_out, blocks_message_debug_1, print]
- [epy_block_0, packet_out, digital_crc_append_0, in]
- [epy_block_0_0, feedback_out, epy_block_1_0, feedback_in]
- [epy_block_0_0, packet_out, blocks_message_debug_1_0, print]
- [epy_block_0_0, packet_out, digital_crc_append_0_0, in]
- [epy_block_0_1, feedback_out, epy_block_1_1, feedback_in]
- [epy_block_0_1, packet_out, blocks_message_debug_1_1, print]
- [epy_block_0_1, packet_out, digital_crc_append_0_1, in]
- [epy_block_1, addr_out, epy_block_0, addr_in]
- [epy_block_1, msg_out, epy_block_0, msg_in]
- [epy_block_1_0, addr_out, epy_block_0_0, addr_in]
- [epy_block_1_0, msg_out, epy_block_0_0, msg_in]
- [epy_block_1_1, addr_out, epy_block_0_1, addr_in]
- [epy_block_1_1, msg_out, epy_block_0_1, msg_in]
- [epy_block_3, pdu_out, blocks_message_debug_0, print]
- [epy_block_3, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [epy_block_3_0, pdu_out, blocks_message_debug_0_0, print]
- [epy_block_3_0, pdu_out, pdu_pdu_to_tagged_stream_2_0, pdus]
- [epy_block_3_1, pdu_out, blocks_message_debug_0_1, print]
- [epy_block_3_1, pdu_out, pdu_pdu_to_tagged_stream_2_1, pdus]
- [epy_block_4_0, ack_out, epy_block_0, ack_in]
- [epy_block_4_0, ack_reply_out, digital_crc_append_0, in]
- [epy_block_4_0, msg_out, epy_block_1, msg_in]
- [epy_block_4_0_0, ack_out, epy_block_0_0, ack_in]
- [epy_block_4_0_0, ack_reply_out, digital_crc_append_0_0, in]
- [epy_block_4_0_0, msg_out, epy_block_1_0, msg_in]
- [epy_block_4_0_1, ack_out, epy_block_0_1, ack_in]
- [epy_block_4_0_1, ack_reply_out, digital_crc_append_0_1, in]
- [epy_block_4_0_1, msg_out, epy_block_1_1, msg_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_1, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_1_1, '0', blocks_tagged_stream_mux_0_1, '1']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_repack_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_2_0, '0', blocks_repack_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_2_1, '0', blocks_repack_bits_bb_0_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_2, print]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_2_0, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, digital_crc_check_0_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0_1, pdus, digital_crc_check_0_0_1, in]
- [pdu_tagged_stream_to_pdu_0_1, pdus, blocks_message_debug_2_1, print]
- [pdu_tagged_stream_to_pdu_0_1, pdus, epy_block_3_1, pdu_in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0_1_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_const_sink_x_1_0_1, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_1_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_const_sink_x_1_0_1_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [soapy_bladerf_source_0_1, '0', digital_symbol_sync_xx_0_1_0_1, '0']
- [soapy_bladerf_source_0_1, '0', qtgui_const_sink_x_1_0_1_1, '0']
- [soapy_bladerf_source_0_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0_1_0_1, '0']
- [virtual_source_0_0, '0', digital_symbol_sync_xx_0_1_0_0, '0']
- [virtual_source_0_1, '0', digital_symbol_sync_xx_0_1_0, '0']
- [virtual_source_1, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', epy_block_4_0, pdu_in]
- [virtual_source_3_0, '0', epy_block_4_0_0, pdu_in]
- [virtual_source_3_1, '0', epy_block_4_0_1, pdu_in]
- [virtual_source_4, '0', blocks_add_xx_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
